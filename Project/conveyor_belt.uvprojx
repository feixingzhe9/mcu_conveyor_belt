# Keil uVision project conveyor_belt.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: conveyor_belt +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../OBJ/test.bin ../OBJ/conveyor_belt.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\Modules;..\HARDWARE;..\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c common.c platform.c
  group Task
    ../Task/: led_task.c can_protocol_task.c conveyor_belt_task.c sanwei_rfid_task.c door_ctrl.c
  group Modules
    ../Modules/: can_fifo.c conveyor_belt.c motor_driver.c photoelectric_switch.c sanwei_rfid.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: can.c timer.c usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_exti.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group Readme
    ../: Readme.txt
